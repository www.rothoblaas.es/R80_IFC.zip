Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 3d22e3c3-731c-418b-bfad-f11afdb8e27e, NumberOfSaves: 46], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_Plate_R80_80100L_200mm.ifc
Time: 2025-08-19T10:53:14
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcDiscreteAccessory: Collegamenti strutturali : ROTHOB_Rothoblaas_Plate_R80 : R80100L_185x110x369mm
In: 0_Rothoblaas
Type - Material: ROTHOB_Rothoblaas_CarbonSteel_S235_DACCOAT
Type - Generale - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_Plate_R80; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: www.rothoblaas.com/products/fastening/brackets-and-plates/post-bases/r80; Revision: 000; UniClass2015Code: Pr_20_76_64_01; UniClass2015Title: Adjustable post bases; UniClass2015Version: Products v1.38; Version: 001
Type - Vincoli - Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_S235_DACCOAT
Type - Quote - HoleQuantity_nhØ12mm: 8; HoleQuantity_nvØ5mm: 16; HoleQuantity_nvØ7.5mm: 8; Length_L: 110 mm; Width_B: 185 mm
Type - Dati identità - Descrizione: Adjustable post base; Nome del tipo: R80100L_185x110x369mm; Numero OmniClass: 23.13.23.11.19.13; Produttore: info@rothoblaas.com
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_76_64_01 - Adjustable post bases; CECode: n/a; CETitle: n/a; CodePerformance: n/a; Color: Grey; Constituents: n/a; DurationUnit: Years; ExpectedLife: 50; Features: Support for timber columns and post bases as bearing elements; Finish: DAC COAT coating; Grade: n/a; GTIN: 8059386079942; ICC-ESCode: DrJ Listing 2406-121; ICC-ESTitle: n/a; Manufacturer_x: info@rothoblaas.com; Material: S235 Carbon steel with DAC COAT coating; MinWeight: 3.605 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: R80100L; ModelReference: n/a; Name: Plate; Nome famiglia: ROTHOB_Rothoblaas_Plate_R80; NominalLength: 110 mm; NominalWidth: 185 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 185x110x369 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Grey
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Plate; Category: Pr_20_76_64_01 - Adjustable post bases
Pset_QuantityTakeOff - Reference: R80100L_185x110x369mm
Vincoli - Host: Livello : 0_Rothoblaas; Livello: 0_Rothoblaas; Livello abaco: 0_Rothoblaas; Quota altimetrica da livello: 0 mm
Fasi - Fase di creazione: Stato di Progetto
Quote - Area: 0.101742 m2; CentralElementHP: 96 mm; ColumnHeightPosition: 208 mm; Height_H: 339 mm; HeightPosition: 200 mm; HeightPosition_Ctrl: 200 mm; Volume: 0.000461764 m3
Altro - Famiglia: ROTHOB_Rothoblaas_Plate_R80; Famiglia e tipo: ROTHOB_Rothoblaas_Plate_R80: R80100L_185x110x369mm; ID tipo: 524935; NominalHeight: 339 mm; Tipo: R80100L_185x110x369mm
